SRC_URI += "file://user_2018-04-13-12-35-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

